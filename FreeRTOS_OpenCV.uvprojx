# Keil uVision project FreeRTOS_OpenCV.uvprojx, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_OpenCV
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\c-Json;.\dht11;.\FatFs;.\FreeRTOS;.\IIC;.\led;.\Listings;.\My_SPI;.\Objects;.\OLED;.\RTE;.\srf05;.\USART1;.\user;.\easylogger\inc;.\easylogger\port;.\easylogger\src;.\esp01;.\app;.\MQTT;.\ov2640;.\http;.\ov2640;.\dma
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./user/: main.c test.c test.h
  group My_SPI
    ./My_SPI/: my_spi.c my_spi.h w25q64.c w25q64.h
  group FatFs
    ./FatFs/: diskio.c diskio.h ff.c ffconf.h ff.h ffsystem.c ffunicode.c ff_port.c
  group FreeRTOS
    ./FreeRTOS/: atomic.h croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h heap_4.c list.c list.h message_buffer.h FreeRTOSConfig.h mpu_prototypes.h mpu_wrappers.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.c stream_buffer.h task.h tasks.c timers.c timers.h
  group USART1
    ./USART1/: myusart1.c myusart1.h
  group led
    ./led/: myled.c myled.h
  group dht11
    ./dht11/: dht11.c dht11.h mydelay.c mydelay.h
  group srf05
    ./srf05/: mytime.c mytime.h
  group IIC
    ./IIC/: MyIIC.c MyIIC.h
  group OLED
    ./OLED/: oled.c oled.h ssd1306.c ssd1306.h
  group c-Json
    ./c-Json/: cJSON.c cJSON.h
  group easylogger
    ./easylogger/inc/: elog.h elog_cfg.h
    ./easylogger/port/: elog_port.c
    ./easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group esp01
    ./esp01/: eso01.c esp01.h
  group app
    ./app/: app.c app.h device_config.h
  group MQTT
    ./MQTT/: my_mqtt.c my_mqtt.h mqtt_app.c mqtt_app.h
  group http
    ./http/: Http_client.c Http_client.h
  group ov2640
    ./ov2640/: Camer_task.c Camer_task.h My_dcmi.c My_dcmi.h Ov2640.c Ov2640.h Ov2640cfg.h Sccb.c Sccb.h
  group DMA
    ./dma/: mydma.c mydma.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:DCMI 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
